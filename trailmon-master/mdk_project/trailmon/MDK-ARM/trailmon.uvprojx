# Keil uVision project trailmon.uvprojx, settings and files
target trailmon (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F303VE STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x08000000-0x807FFFF) CLOCK(72000000) FPU2 CPUTYPE("Cortex-M4")
  output: trailmon
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xE
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F3xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_uart_ex.c stm32f3xx_hal_spi.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_rtc.c stm32f3xx_hal_uart.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_adc.c stm32f3xx_hal_flash.c stm32f3xx_hal_dma.c stm32f3xx_hal_gpio.c
  group Application/MDK-ARM
    ./: startup_stm32f303xe.s
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
  group Application/User
    ../Src/: stm32f3xx_hal_msp.c fatfs.c stm32f3xx_it.c main.c user_diskio.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff_gen_drv.c ff.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0
